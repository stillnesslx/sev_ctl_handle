# Keil uVision project sev_ctl_handle.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: sev_ctl_handle
  c flags: Optim=1 wLevel=2
  c define: USE_FULL_ASSERT,USE_STDPERIPH_DRIVER
  c include: ..\app;..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\lib\freeRTOS\include;..\lib\STM32F10x_StdPeriph_Driver\inc;..\lib\freeRTOS\portable;..\lib\CMSIS\CM3\CoreSupport
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group app
    ../app/: main.c stm32f10x_it.c bsp.c timertest.c serial.c comtest.c oled.c oo_oled.c oledfont.c
  group CMSIS
    ../lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group boot
    ../app/: startup_stm32f10x_hd.s
  group freeRTOS
    ../lib/freeRTOS/: list.c queue.c tasks.c
    ../lib/freeRTOS/portable/: port.c
    ../lib/freeRTOS/portable/MemMang/: heap_2.c
  group STM32F10x_StdPeriph_Driver
    ../lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group alg
    ../lib/alg/: fifo_buffer.c
